# add VyOS patches
require vyos-patches.inc
