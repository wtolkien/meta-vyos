# let VyOS control dnsmasq start/stop
SYSTEMD_AUTO_ENABLE_${PN} = "disable"
