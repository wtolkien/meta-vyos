COMPATIBLE_HOST = '(x86_64.*|i.86.*|arm.*|aarch64.*|mips.*)-(linux.*|freebsd.*)'
RDEPENDS_${PN}_remove_edgerouter = "grub parted e2fsprogs-mke2fs"
