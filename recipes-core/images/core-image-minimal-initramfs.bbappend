PACKAGE_INSTALL += "kernel-modules"
