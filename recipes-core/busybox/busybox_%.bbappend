SRC_URI += "file://fragment.cfg"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
