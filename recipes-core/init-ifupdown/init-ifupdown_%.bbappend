# disable /etc/init.d/networking startup script (VyOS takes care of this)

INITSCRIPT_PARAMS = "remove"
